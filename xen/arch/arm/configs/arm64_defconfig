## xen/arch/arm/configs/arm64_defconfig
```kconfig
CONFIG_TEE=y
CONFIG_OPTEE=y
CONFIG_DEBUG=y
CONFIG_DEBUG_INFO=y
CONFIG_VERBOSE_DEBUG=y
```
